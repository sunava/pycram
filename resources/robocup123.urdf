Commit message: kill me

File: resources/robocup123.urdf (robot description, URDF)
Before this commit: robot iai-kitchen, 102 links, 101 joints
Joints:
- joint shelf_hohc:kitchen_cabinet:shelf_origin_joint: origin xyz=5.6 6.2 0.0 rpy=0.0 0.0 3.23 -> xyz=5.45 6.2 0.0 rpy=0.0 0.0 3.23
